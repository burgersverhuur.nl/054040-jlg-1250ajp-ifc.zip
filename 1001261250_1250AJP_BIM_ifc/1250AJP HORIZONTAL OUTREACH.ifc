Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-10-29T14:12:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 29 14:12:37 2020 * Host: CHTSW00356 * Database: C:\Users\174558\AppData\Local\Temp\{E6F77E66-3005-4EB4-9CC8-0236C4105AE9}\ifc * Database version: 5507 * Database creation date: Thu Oct 29 14:12:25 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 29 14:12:25 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 29 14:12:25 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcTransportElement: Height=21.00m(68'-11")_Reach=18.51m(60'-9")_230kg(500lbs), 1001261250_1250AJP:Height=21.00m(68'-11")_Reach=18.51m(60'-9")_230kg(500lbs):605040
In: Level 1
Type - Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Steel, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Plastic_Red, JLG_Rubber_Black, JLG_Paint_Silver Grey
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Ultra Series Boom Lifts; ProductionYear: n/a
